# Keil uVision project ble_mesh_dfu_becon.uvprojx, settings and files
target nrf51822_s110_ac (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_mesh_dfu_becon +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_DFU_APP_SUPPORT NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10028
  c misc: --c99
  c include: ..\application;..\arm;..\arm\Include;..\boad_support;..\bsp;..\device;..\device_manager;..\device_manager\config;..\dfu;..\libs;..\nrf_ble;..\nrf_drivers;..\nrf_drivers\hal;..\nrf_libraries;..\nrf_libraries\util;..\nrf_softdevice;..\nrf_softdevice\headers;..\rbc_mesh;..\rbc_mesh\include
  memory RVCT4: ROM 0x16000 size 0xc000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ./: dispose_pkt.c main.c pwm.c switch_color.c flash_opt.c changecolor.c
  group rbc_mesh
    ../rbc_mesh/src/: mesh_aci.c mesh_srv.c radio_control.c rbc_mesh.c serial_handler.c serial_queue.c timer_control.c timeslot_handler.c transport_control.c trickle.c
  group libs
    ../libs/: spi_slave.c
  group dfu
    ../dfu/: ble_dfu.c bootloader_util_arm.c dfu_app_handler.c
  group Board Support
    ../bsp/: bsp.c
  group Device
    ../device/: arm_startup_nrf51.s system_nrf51.c
  group nRF_BLE
    ../nrf_ble/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h ble_srv_common.c device_manager_cnfg.h
    ../device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../nrf_drivers/: app_uart.h app_uart_fifo.c pstorage.c pstorage.h pstorage_platform.h
    ../nrf_drivers/hal/: nrf_delay.c
  group nRF_Libraries
    ../nrf_libraries/: app_button.c app_button.h app_error.c app_error.h app_fifo.c app_fifo.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h app_trace.c app_trace.h ble_sensorsim.c ble_sensorsim.h nrf_assert.c nrf_assert.h retarget.c
  group nRF_SoftDevice
    ../nrf_softdevice/: softdevice_handler.c
